# Keil uVision project diansai_zhunbei.uvprojx, settings and files
target diansai_zhunbei (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diansai_ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\CMSIS;..\main;..\lcd;..\AD_DA;..\NVIC;..\PID;..\PWM;..\TIM;..\SPI_UART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../main/: main.c stm32f10x_it.c sys.c
    ../lcd/: lcd.c oled.c
    ../AD_DA/: ADC.c adc_Double.c DAC.c
    ../NVIC/: exti_key.c
    ../PID/: PID_position.c PID_UP.c
    ../PWM/: PWM.c PWM_IC.c
    ../SPI_UART/: SPI_1.c UART_1.c NRF24L01.c bsp_usart_dma.c
    ../TIM/: TIM.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../startup/: startup_stm32f10x_hd.s
  group LIB
    ../src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
